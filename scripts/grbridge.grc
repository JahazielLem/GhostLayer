options:
  parameters:
    generate_options: no_gui
    id: bridge
    output_language: python
    run_options: run
    title: Deamon Bridge
  states: {}

blocks:
- name: bandpass
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: bandwidth/2
    low_cutoff_freq: '-bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: bandwidth/50
    win: window.WIN_HAMMING
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: coding_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '916000000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_header
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pluto_source
  id: variable
  parameters:
    value: '"ip:pluto.local"'
  states: {}
- name: samp_mult
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bandwidth*samp_mult
  states: {}
- name: spread_factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: tx_bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: '918000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: int(tx_bandwidth)
  states: {}
- name: tx_spread_factor
  id: variable
  parameters:
    value: '7'
  states: {}
- name: tx_zmq_address
  id: variable
  parameters:
    value: '"tcp://0.0.0.0:5007"'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://0.0.0.0:5009"'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: bandpass
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_gain
    bandwidth: tx_bandwidth
    buffer_size: '22768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_frequency
    samplerate: tx_samp_rate
    type: fc32
    uri: pluto_source
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '22768'
    filter_source: '''Auto'''
    frequency: frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_source
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: bandwidth
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,False]'
    samp_rate: samp_rate
    sf: spread_factor
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: tx_bandwidth
    cr: '1'
    frame_zero_padd: '10000'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: tx_samp_rate
    sf: tx_spread_factor
    sync_word: '[0x12]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: tx_samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    hwm: '1000'
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tx_zmq_address
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_rx_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [lora_rx_0, '0', zeromq_pub_sink_0, '0']
- [lora_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', iio_pluto_sink_0, '0']
- [zeromq_pull_msg_source_0, out, lora_tx_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
